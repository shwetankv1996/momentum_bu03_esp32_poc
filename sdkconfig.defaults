## sdkconfig.defaults
```kconfig
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
CONFIG_ESP_TASK_WDT_INIT=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=4096
```
